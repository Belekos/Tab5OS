#include <ArduinoJson.h>
#include <vector>
#include <string>
#include <map>
#include <fstream>
#include <sstream>
#include <memory>
#include <algorithm>
#include <cctype>
#include <cstdio>
#include <cstdlib>
#include <cstring>
class String {
 std::string text;
 public:
 String()=default;String(const char* value):text(value?value:""){}
 const char* c_str()const{return text.c_str();}
 void toLowerCase(){for(auto& c:text)c=char(std::tolower(static_cast<unsigned char>(c)));}
 int compareTo(const String& other)const{return text.compare(other.text);}
 bool operator!=(const String& other)const{return text!=other.text;}
};
static std::map<std::string,std::string> files;
class File {
 const std::string* data=nullptr;size_t at=0;
 public:
 File()=default;explicit File(const std::string* source):data(source){}
 operator bool()const{return data!=nullptr;}bool isDirectory()const{return false;}
 size_t size()const{return data?data->size():0;}void close(){data=nullptr;}
 int peek(){return data&&at<data->size()?uint8_t((*data)[at]):-1;}
 int read(){int value=peek();if(value>=0)++at;return value;}
 size_t readBytes(char* output,size_t n){size_t count=0;while(count<n){int v=read();if(v<0)break;output[count++]=char(v);}return count;}
};
struct FS {
 bool exists(const char* path){return files.count(path)!=0;}
 File open(const char* path,int){auto i=files.find(path);return i==files.end()?File():File(&i->second);}
} tab5FS;
constexpr int FILE_READ=0;
static const char* RADIO_FILE="/System/radios.json",*LEGACY_RADIO_FILE="/radios.json";
struct Tab5AudioStation{String name,style,url;};
struct Allocator:ArduinoJson::Allocator {
 size_t retained=0,peak=0;std::map<void*,size_t> sizes;
 void* allocate(size_t n)override{auto p=std::malloc(n);if(p){sizes[p]=n;retained+=n;peak=std::max(peak,retained);}return p;}
 void deallocate(void* p)override{if(p){retained-=sizes.at(p);sizes.erase(p);}std::free(p);}
 void* reallocate(void* p,size_t n)override{const size_t before=p?sizes.at(p):0;auto q=std::realloc(p,n);if(q){if(p)sizes.erase(p);sizes[q]=n;retained=retained-before+n;peak=std::max(peak,retained);}return q;}
} allocator;
static ArduinoJson::Allocator* tab5JsonAllocator(){return &allocator;}
class Tab5AudioEngine {
 public:bool _sdAvailable=true;std::vector<Tab5AudioStation> _stations;size_t _stationIndex=0;
 void addFallbackStations();void loadStations();
};
// Exact current production constants and functions, generated by run.py.
#include "catalogue-production.inc"
static unsigned checks=0;
static void check(bool value,const char* what){if(!value){fprintf(stderr,"FAIL %s\n",what);exit(1);}++checks;}
int main(int argc,char** argv){
 check(argc==2,"real 600-station pack path supplied");std::ifstream input(argv[1],std::ios::binary);std::ostringstream raw;raw<<input.rdbuf();files[RADIO_FILE]=raw.str();
 Tab5AudioEngine engine;engine.loadStations();check(engine._stations.size()==600,"native production loader accepts complete real 600-station pack");check(allocator.retained==0,"JSON DOM freed after loading");
 const size_t peak=allocator.peak;
 files[RADIO_FILE]="  [ {\"name\":\"Kept\",\"url\":\"https://a/live\",\"style\":\"AA/news\",\"codec\":\"MP3\",\"metadata\":\"ignored\"},{\"name\":\"Disabled\",\"url\":\"https://b/live\",\"enabled\":false}]";
 engine.loadStations();check(engine._stations.size()==1&&!std::strcmp(engine._stations[0].name.c_str(),"Kept"),"filtered legacy root arrays preserve enabled and style fields");
 files[RADIO_FILE]="{\"radios\":[";for(unsigned i=0;i<830;++i){if(i)files[RADIO_FILE]+=",";files[RADIO_FILE]+="{\"name\":\"Station\",\"url\":\"https://test/"+std::to_string(i)+"\"}";}files[RADIO_FILE]+="]}";
 engine.loadStations();check(engine._stations.size()==800,"native station ceiling bounded at800");
 files[RADIO_FILE]="bad json";engine.loadStations();check(engine._stations.empty(),"malformed catalogue leaves no partial stations");
 files[RADIO_FILE]=std::string(262145,' ');engine.loadStations();check(engine._stations.empty(),"oversized input rejected before JSON allocation");
 files.clear();engine.loadStations();check(engine._stations.empty(),"no imposed musical station on fresh setup");
 check(allocator.retained==0,"all catalogue parsing paths free DOM allocations");
 printf("PASS %u checks: exact production radio loader, actual600pack, legacyarray, filteredJSON, 800ceiling, invalid and oversized input; JSON peak %zu bytes on host.\n",checks,peak);
}
